# Keil uVision project lr1110_updater.uvprojx, settings and files
target stm32l476rg (6140000::V6.14::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lr1110_updater
  AfterMake: fromelf --bincombined --output=@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER, LV_CONF_INCLUDE_SIMPLE
  c misc: -Wno-deprecated-register
  c include: ..\lr1110_driver\src;..\STM32L4xx_HAL_Driver\Inc;..\STM32L4xx_HAL_Driver\Inc\Legacy;..\CMSIS\Core\Include;..\CMSIS\Device\ST\STM32L4xx\Include;..\application\inc;..\system\inc;..\display_touch\inc;..\lvgl;..\lvgl\src;..\lvgl\src\lv_core;..\lvgl\src\lv_draw;..\lvgl\src\lv_font;..\lvgl\src\lv_hal;..\lvgl\src\lv_misc;..\lvgl\src\lv_objx;..\lvgl\src\lv_themes;..\lr1110_modem_driver\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group application
    ../application/src/: lr1110_hal.c lr1110_firmware_update.c main.c gui.c lr1110_modem_hal.c
  group lr1110_driver
    ../lr1110_driver/src/: lr1110_bootloader.c lr1110_regmem.c lr1110_system.c
  group stm32l4xx_hal_driver
    ../STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_spi.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c stm32l4xx_ll_i2c.c stm32l4xx_ll_dma.c stm32l4xx_ll_lptim.c
  group CMSIS
    ../CMSIS/Device/ST/STM32L4xx/Source/: system_stm32l4xx.c
    ../CMSIS/Device/ST/STM32L4xx/Source/arm/: startup_stm32l476xx.s
  group system
    ../system/src/: system_clock.c system_gpio.c system_spi.c system_uart.c system_it.c system_i2c.c system.c system_time.c system_uart_retarget.c system_lptim.c
  group display_touch
    ../display_touch/src/: display.c touch.c lv_port_disp.c lv_port_indev.c semtech_logo.c
  group lvgl/lv_core
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_debug.c
  group lvgl/lv_draw
    ../lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lvgl/font
    ../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group lvgl/lv_hal
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/lv_misc
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c lv_printf.c
  group lvgl/objx
    ../lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lvgl/themes
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lr1110_modem_driver
    ../lr1110_modem_driver/src/: lr1110_modem_system.c lr1110_modem_lorawan.c
software components: Compiler:I/O:STDOUT 1.2.0
